Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Capri-Sofa 2 seater - ver4.ifc
Time: 2024-12-10T14:38:52
Author: Utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (4)
Name
 | Capri-Sofa 2 seater_0 - ObjectType: SketchupGroup
 | Capri-Sofa 2 seater_1 - ObjectType: SketchupGroup
 | Capri-Sofa 2 seater_2 - ObjectType: SketchupGroup
 | Capri-Sofa 2 seater_3 - ObjectType: SketchupGroup
